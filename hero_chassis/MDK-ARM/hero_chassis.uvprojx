# Keil uVision project hero_chassis.uvprojx, settings and files
target hero_chassis (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: hero_chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP;../BSP;../protocol;../components;../struct_typedef;..\power_control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: bsp_can.c bsp_can.h delay.c delay.h bsp_uart.c bsp_uart.h bsp_referee.c bsp_referee.h
  group APP
    ../APP/: pid.c pid.h chassis_task.c chassis_task.h gimbal_task.c gimbal_task.h trigger_task.c trigger_task.h supercap.c supercap.h referee.c referee.h referee_UI.c referee_UI.h
  group protocol
    ../protocol/: protocol.h
  group components
    ../components/: fifo.c fifo.h CRC8_CRC16.c CRC8_CRC16.h
  group struct_typedef
    ../struct_typedef/: struct_typedef.h
  group power_control
    ../power_control/: chassis_power_control.c chassis_power_control.h
software components: CMSIS:CORE 4.3.0
